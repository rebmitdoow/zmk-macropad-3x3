## boards/shields/macropad3x3/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD3X3

config ZMK_KEYBOARD_NAME
    default "Macropad 3x3"

endif
```
